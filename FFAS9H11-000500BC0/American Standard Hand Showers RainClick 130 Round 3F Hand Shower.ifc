Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-09-29T11:52:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 29 11:52:05 2021 * Host: LAPTOP-GL8UO08N * Database: C:\Users\CHATPONG\AppData\Local\Temp\{8258BAB3-5321-40DB-BB37-2679A62975BA}\ifc * Database version: 5507 * Database creation date: Wed Sep 29 11:52:04 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 29 11:52:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 29 11:52:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: 130 Round 3F Hand Shower FFAS9H11-000500BC0, American Standard Hand Showers RainClick 130 Round 3F Hand Shower:130 Round 3F Hand Shower FFAS9H11-000500BC0:353466
In: Level 1
Material: Chrome, White
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_DistributionFlowElementCommon - Reference: 130 Round 3F Hand Shower FFAS9H11-000500BC0
